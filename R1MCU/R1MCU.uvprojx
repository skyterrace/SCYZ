# Keil uVision project R1MCU.uvprojx, settings and files
target R1MCU (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: R1MCU
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,EMPL_TARGET_STM32,MPU6050
  c include: .\FWlib\inc;.\CM3;.\usr;.\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group usr
    ./usr/: clock_calendar.c main.c stm32f10x_it.c key.c eeprom.c R1DEF.c behaviors.c stepmotor.c GUI.c Lcd_Driver.c
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_tim.c
  group ASM
    ./startup/: startup_stm32f10x_md.s
software components: CMSIS:CORE 4.1.0
